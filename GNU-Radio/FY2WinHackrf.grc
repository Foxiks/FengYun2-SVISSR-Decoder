options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: (samp_rate*1.0)/(symbol_rate*1.0)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 660e3
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: AMP Gain
    orient: Qt.Horizontal
    start: '0'
    step: '14'
    stop: '14'
    value: '14'
  states: {}
- name: variable_qtgui_range_0_0
  id: variable_qtgui_range
  parameters:
    label: LNA Gain
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '40'
    value: '40'
  states: {}
- name: variable_qtgui_range_0_0_0
  id: variable_qtgui_range
  parameters:
    label: VGA Gain
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '2'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '4096'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '8.7e-3'
    gain_omega: 8.7e-3**2/4.0
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.000005'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.002'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf
    bb_gain0: variable_qtgui_range_0_0_0
    freq0: 16875e5
    gain0: variable_qtgui_range_0
    gain_mode0: 'False'
    if_gain0: variable_qtgui_range_0_0
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '512'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.50'
    decim: '1'
    gain: '1'
    ntaps: '31'
    samp_rate: samp_rate
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}

connections:
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_diff_decoder_bb_0, '0']
- [blocks_repeat_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [dc_blocker_xx_0, '0', analog_agc_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_repeat_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_complex_to_real_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
